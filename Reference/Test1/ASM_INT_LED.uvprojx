# Keil uVision project ASM_INT_LED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ASM_INT_LED +hex
  AfterMake: fromelf  --bin  --output=ASM_INT_LED.bin ./Objects/ASM_INT_LED.axf
  AfterMake: fromelf  --text  -a -c  --output=ASM_INT_LED.dis ./Objects/ASM_INT_LED.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: led_ir.s
