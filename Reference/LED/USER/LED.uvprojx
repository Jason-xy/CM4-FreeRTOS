# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F411xE
  c include: ..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\CORE;..\HARDWARE\LED
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group README
    ../: README.TXT
software components: Device:Startup 2.5.0
